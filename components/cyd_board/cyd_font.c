#include <stddef.h>

#include "cyd_board.h"

/* Classic 5x7 column-major glyphs: each byte is one column, bit 0 at the top. */
static const uint8_t s_letters[26][5] = {
    {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43},
};

static const uint8_t s_digits[10][5] = {
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00}, {0x42,0x61,0x51,0x49,0x46},
    {0x21,0x41,0x45,0x4B,0x31}, {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03}, {0x36,0x49,0x49,0x49,0x36},
    {0x06,0x49,0x49,0x29,0x1E},
};

static const struct {
    char c;
    uint8_t cols[5];
} s_symbols[] = {
    {':', {0x00,0x36,0x36,0x00,0x00}}, {'-', {0x08,0x08,0x08,0x08,0x08}},
    {'/', {0x20,0x10,0x08,0x04,0x02}}, {'.', {0x00,0x60,0x60,0x00,0x00}},
    {'>', {0x00,0x41,0x22,0x14,0x08}}, {'<', {0x08,0x14,0x22,0x41,0x00}},
    {'(', {0x00,0x1C,0x22,0x41,0x00}}, {')', {0x00,0x41,0x22,0x1C,0x00}},
    {'%', {0x23,0x13,0x08,0x64,0x62}}, {'_', {0x40,0x40,0x40,0x40,0x40}},
    {'!', {0x00,0x00,0x5F,0x00,0x00}}, {'?', {0x02,0x01,0x51,0x09,0x06}},
};

static const uint8_t *glyph_for(char c)
{
    if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
    if (c >= 'A' && c <= 'Z') return s_letters[c - 'A'];
    if (c >= '0' && c <= '9') return s_digits[c - '0'];
    for (size_t i = 0; i < sizeof(s_symbols) / sizeof(s_symbols[0]); ++i) {
        if (s_symbols[i].c == c) return s_symbols[i].cols;
    }
    return NULL; /* space and unknown characters render as blank */
}

int cyd_text_width(const char *text, int scale)
{
    int n = 0;
    for (const char *p = text; *p; ++p) n++;
    return n > 0 ? (n * 6 - 1) * scale : 0;
}

void cyd_draw_text(cyd_canvas_t *c, const char *text, int x, int y, int scale, uint16_t color)
{
    /* Skip text that does not touch this stripe. */
    if (y + 7 * scale <= c->y0 || y >= c->y0 + c->h) {
        return;
    }
    for (const char *p = text; *p; ++p, x += 6 * scale) {
        const uint8_t *glyph = glyph_for(*p);
        if (glyph == NULL) continue;
        for (int col = 0; col < 5; ++col) {
            for (int row = 0; row < 7; ++row) {
                if (glyph[col] & (1u << row)) {
                    cyd_fill_rect(c, x + col * scale, y + row * scale, scale, scale, color);
                }
            }
        }
    }
}
